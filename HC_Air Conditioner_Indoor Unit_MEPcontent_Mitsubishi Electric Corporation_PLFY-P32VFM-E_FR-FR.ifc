Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2016-11-01T09:38:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 01 09:38:15 2016 * Host: B3ROBRAWR2784 * Database: C:\Users\CTO\AppData\Local\Temp\{E4F7CC40-5BCC-4DAE-8CB7-4FA2658C728A}\ifc * Database version: 5507 * Database creation date: Tue Nov 01 09:38:15 2016 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Nov 01 09:38:15 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 01 09:38:15 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Identity Data - Design Option: Main Model
Other - Category: Project Information; S4R_Use_nominal_diameter: yes; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcUnitaryEquipment: PLFY-P32VFM-E, HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Electric Corporation:PLFY-P32VFM-E:1162888
In: V00
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 060-060-060, Color RGB 245-245-245, Color RGB 187-080-046, Color RGB 050-050-050, Color RGB 120-120-120
Type - Dimensions - Depth: 570 mm; Drain Diameter: 32 mm; HEIGHT: 208 mm; Refrigerant Gas Diameter: 12.7 mm; Refrigerant Liquid Diameter: 6.35 mm; Supply Air Diameter: 73.4 mm; WIDTH: 570 mm
Type - Electrical - Hertz: 50 Hz; Phase: 1; Voltage: 240.002 V
Type - Identity Data - Content Supplier URL: www.MEPcontent.com; Copyright: ©Mitsubishi Electric Corporation / Stabiplan International BV; DEEPLINK: http://pro.confort.mitsubishielectric.fr/produits/gamme-drv-city-multi/unites-interieures-cassette/; Description: Cassette 4 voies 600x600; EMCS Version: 4.0; Family Version: 10.20; Manufacturer: Mitsubishi Electric Corporation; Model: PLFY-P32VFM-E; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Revit Version: 2015; Type Name: PLFY-P32VFM-E; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Mechanical - Loads - Airflow Rate (m3/min): 9.5; Cooling Capacity (kW): 3.6; Cooling Current (A): 0.23; Cooling Power Input (kW): 0.02; External Static Pressure (Pa): 0; Fan Motor Output (kW): 0.05; Heating Capacity (kW): 4; Heating Current (A): 0.18; Heating Power Input (kW): 0.02; Sound Pressure Level (dB(A)): 34; Unit Weight (kg): 15
Type - Other - Category: Mechanical Equipment; Family Name: HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Electric Corporation; Fan Quantity: 1; Fan Type: Turbo; ISCUSTOM: no; Refrigerant Type: R410A
Type - Text - ARTICLEDESCRIPTION: Cassette 4 voies 600x600; ARTICLENUMBER: PLFY-P32VFM-E; ETIM article class: EC000403; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; PRODUCTLINE: City Multi PLFY-P-VFM-E; TYPE: PLFY-P32VFM-E
Pset_ManufacturerTypeInformation - ArticleNumber: PLFY-P32VFM-E; Manufacturer: Mitsubishi Electric Corporation
Constraints - Offset: 0 mm
Dimensions - Area: 7.26503 m2; Ceiling Offset: 0 mm; Volume: 3.20488 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Flow Refrigerant Gas: 0 m3/s; Flow Refrigerant Liquid: 0 m3/s; System Classification: Power,Sanitary,Hydronic Supply,Supply Air
Mechanical - Flow - Supply Air Flow: 0 m3/s
Other - Family: HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Electric Corporation: PLFY-P32VFM-E; Family and Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Electric Corporation: PLFY-P32VFM-E; Offset from Ceiling: 0 mm; Offset Start: -127 mm; Service Offset: 0 mm; Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Electric Corporation: PLFY-P32VFM-E; Type Id: HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Electric Corporation: PLFY-P32VFM-E
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Service Space: no
